# Keil uVision project ISO-STM32.uvprojx, settings and files
target 单任务 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ISO-STM32 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\Libraries\FWlib\inc;..\..\User;..\..\User\led;..\..\FreeRTOS\inc;..\..\SYSTEM\sys;..\..\SYSTEM\delay;..\..\SYSTEM\usart2;..\..\SYSTEM\usart3;..\..\HARDWARE\MS5837;..\..\HARDWARE\OLED;..\..\HARDWARE\LED;..\..\HARDWARE\TABLE;..\..\HARDWARE\FishAgreement;..\..\HARDWARE\PWM;..\..\HARDWARE\TIMER;..\..\HARDWARE\DEVICE;..\..\HARDWARE\IIC;..\..\HARDWARE\ADC;..\..\HARDWARE\TASK;..\..\HARDWARE\CONTROL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group DOC
    ../../Doc/: readme.txt
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLIB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group HARDWARE
    ../../HARDWARE/OLED/: oled.c
    ../../HARDWARE/LED/: led.c
    ../../HARDWARE/TABLE/: table.c
    ../../HARDWARE/FishAgreement/: FishAgreement.c
    ../../HARDWARE/PWM/: PWM_apply.c
    ../../HARDWARE/TIMER/: timer.c
    ../../HARDWARE/DEVICE/: device.c
    ../../HARDWARE/MS5837/: ms5837.c
    ../../HARDWARE/IIC/: myiic.c
    ../../HARDWARE/ADC/: adc.c
    ../../HARDWARE/CONTROL/: control.c
    ../../HARDWARE/TASK/: timetask.c
  group SYSTEM
    ../../SYSTEM/sys/: sys.c
    ../../SYSTEM/delay/: delay.c
    ../../SYSTEM/usart3/: usart3.c
